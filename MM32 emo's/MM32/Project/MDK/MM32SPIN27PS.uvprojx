# Keil uVision project MM32SPIN27PS.uvprojx, settings and files
target MM32SPIN27PS_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.5
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32SPIN2PS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\CODE;..\USER\src;..\USER\inc;..\..\Libraries\seekfree_libraries\common;..\..\\Libraries\seekfree_libraries\board;..\..\Libraries\seekfree_libraries\system;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\..\Libraries\Device\CMSIS\KEIL_Core;..\..\Libraries\Device\MM32SPIN2xx_p\Include;..\..\Libraries\Device\MM32SPIN2xx_p\HAL_Lib\Inc;..\USER\src\新建文件夹;..\USER\src\direction;..\USER\src\LCD;..\USER\src\PID;..\USER\src\MOTOR;..\USER\src\BEEP;..\USER\src\new;..\USER\src\PID_Parameter;..\USER\src\circle;..\USER\src\Threeforks;..\USER\src\curve;..\USER\src\SERIAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group user_c
    ../USER/src/: isr.c main.c
    ../USER/src/direction/: direction.c
    ../USER/src/LCD/: LCD.c
    ../USER/src/MOTOR/: motor.c
    ../USER/src/PID/: PID.c
    ../USER/src/BEEP/: beep.c
    ../USER/src/PID_Parameter/: PID_parameter.c
    ../USER/src/new/: new.c
    ../USER/src/circle/: circle.c
    ../USER/src/Threeforks/: threeforks.c
    ../USER/src/curve/: curve.c
    ../USER/src/SERIAL/: serial.c
  group user_h
    ../USER/inc/: isr.h
    ../USER/src/direction/: direction.h
    ../USER/src/LCD/: LCD.h
    ../USER/src/MOTOR/: motor.h
    ../USER/src/PID/: PID.h
    ../USER/src/BEEP/: beep.h
    ../USER/src/new/: new.h
    ../USER/src/PID_Parameter/: PID_parameter.h
    ../USER/src/circle/: circle.h
    ../USER/src/Threeforks/: threeforks.h
    ../USER/src/curve/: curve.h
    ../USER/src/SERIAL/: serial.h
  group CODE
    ../CODE/: 本文件夹作用.txt
  group board
    ../../Libraries/seekfree_libraries/board/: board.c board.h
  group common
    ../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group startup
    ../../Libraries/Device/MM32SPIN2xx_p/Source/: system_mm32spin2xx_p.c
    ../../Libraries/Device/MM32SPIN2xx_p/Source/KEIL_StartAsm/: startup_mm32spin2xx_p_keil.s
  group doc
    ../../Libraries/doc/: pin_recommend.txt version.txt
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: headfile.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_UART_7725.c SEEKFREE_UART_7725.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group MM32_HAL
    ../../Libraries/Device/MM32SPIN2xx_p/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
    ../../Libraries/Device/MM32SPIN2xx_p/HAL_Lib/Inc/: hal_adc.h hal_bkp.h hal_comp.h hal_crc.h hal_dbg.h hal_div.h hal_dma.h hal_exti.h hal_flash.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_opamp.h hal_pwr.h hal_rcc.h hal_spi.h hal_sqrt.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h dtype.h hal_conf.h hal_device.h hal_redefine.h hal_syscfg.h
